# IAR project Backup of Alarm.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103x8 ST STM32F103x8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32F103xB; DEBUG
  ICCARM.CCIncludePath2: ../inc; ..\FreeRTOS\Source\CMSIS_RTOS\; ..\FreeRTOS\Source\include\; ..\FreeRTOS\Source\portable\IAR\ARM_CM3\; ../../../Common/inc/
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ../inc
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: Alarm.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  group App
    ../src/: cipher.c inout.c main.c manager.c modem.c nRF24L01.c PDU.c radio.c rc.c storage.c
  group FreeRTOS
    ../FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../FreeRTOS/Source/portable/MemMang/: heap_3.c
    ../FreeRTOS/Source/portable/IAR/ARM_CM3/: port.c portasm.s
  group System
    ../src/: startup_stm32f103xb.s system_stm32f1xx.c

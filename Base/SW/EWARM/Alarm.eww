<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Alarm.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\FOB\SW\FOB_3\Keyfob\EWARM\Keyfob.ewp</path>
  </project>
  <batchBuild/>
</workspace>


